# Keil uVision project changetest.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: changetest +hex
  c flags: Optim=1
  c define: STM32F10X_MD
  c misc: --asm
  c include: .\inc;.\src;..\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ./src/: test.c
    ./inc/: test.h
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
