# Keil uVision project Changesample.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105RB STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Changesample +hex
  c flags: Optim=2
  c define: STM32F10X_CL
  c misc: --asm
  c include: .\src;.\inc;..\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../CMSIS/startup/: startup_stm32f10x_cl.s
  group USER
    ./src/: SYS_Init.c UART.c main.c ADS7953.c AD_Sample.c Stat_control.c Timer.c CRC.c DATA_pro.c Flash.c Cal_Sampdata.c Watchdog.c BMSCom_GB.c BMSCom_SAE.c CAN.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
